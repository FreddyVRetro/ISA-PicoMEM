/*
 * This file is part of the ethersrv-linux project
 * Copyright (C) 2017 Mateusz Viste
 */

#include <assert.h>
//#include <dirent.h>
#include <errno.h>
#include <fcntl.h>
#include <string.h>
//#include <sys/statvfs.h> /* statvfs() for diskfree calls */
//#include <sys/stat.h>    /* stat() */
#include <sys/types.h>
#include <stdio.h>
#include <stdint.h>
//#include <stdlib.h>        /* free() */
#include <string.h>
//#include <time.h>        /* time_t, struct tm... */
#include <unistd.h>
//#include <linux/msdos_fs.h>
//#include <sys/ioctl.h>
#include <string.h>

#include "debug.h"


#include "pico/stdlib.h"
#include "f_util.h"
#include "ff.h"
#include "../pm_debug.h"
//#include "../pm_gvars.h"

bool PM_PICO_EnablePSRAM();
bool PM_EnableSD();

//List of files indexed by their "ID"
// ID are then stored to the File "SFT" structure, in the "Cluster number" variable, as Handle is generated by DOS
#define MAXFILES 16

bool pm_fileopened[MAXFILES];
FIL pm_files[MAXFILES]; // 16 Files maximum  > To change to pointer ?

/* Per-search state: DOS can have several searches running at the same time
 * (DELTREE, nested DIR loops...). Each FindFirst grabs a slot, and the slot
 * id travels back and forth in the DOS search block so FindNext can resume
 * exactly where its own search left off. Slots are recycled LRU.
 * 4 slots is enough for the deepest nesting DOS does in practice (DELTREE
 * walks a directory while recursing into its subdirectories). */
#define MAXSEARCH 4

struct srchstate {
  DIR dir;                 /* FatFs directory object of this search */
  char pattern[11];        /* FCB-style search mask */
  unsigned char fattr;     /* requested attributes */
  unsigned char dotstate;  /* 0: emit ".", 1: emit "..", 2: read real entries */
  bool inuse;
  uint32_t lru;
};

static struct srchstate pm_search[MAXSEARCH];
static uint32_t pm_srch_clock = 0;

#include "fs.h" /* include self for control */

#ifdef BOARD_PICOMEM

// The opened files is a list of MAXFILES "FIL" type structure

void init_fobj()
{
   for (uint8_t i=0;i<MAXFILES;i++) pm_fileopened[i]=false;
   for (uint8_t i=0;i<MAXSEARCH;i++) pm_search[i].inuse=false;
   pm_srch_clock=0;
}

void free_fobj(uint8_t fid)
{
  if (fid<MAXFILES) 
  {
    //PM_INFO("!!FREE %d\n",fid);
    pm_fileopened[fid]=false;
  }
}

// Get the file object @ from its ID
FIL *get_fobj(uint8_t fid)
{
  //PM_INFO("Getfobj %d opened? %d\n",fid,pm_fileopened[fid]);
  if ((fid<MAXFILES)&&(pm_fileopened[fid])) 
     {
      //PM_INFO("!!NEW %d\n",fid);
      return &pm_files[fid];
     }
//  PM_INFO("Getfobj fail\n");
  return NULL;
}

// allocate a new file object and get its ID, return NULL if no more objects
FIL *new_fobj(uint8_t *fid)
{
 for (uint8_t i=0;i<MAXFILES;i++)
   if (!pm_fileopened[i]) 
      {
       //PM_INFO("new_fobj id:%d ptr:%x\n",i,&pm_files[i]);
       *fid=i;
       pm_fileopened[i]=true;
       return &pm_files[i];
      }
 return NULL;
}
#endif

/* maps a FatFs FRESULT into the matching DOS error code (0 if no error) */
int fres2doserr(int fr) {
  switch (fr) {
    case FR_OK:                  return(0);
    case FR_NO_FILE:             return(ERR_FILE_NOTFOUND);
    case FR_NO_PATH:             return(ERR_PATH_NOTFOUND);
    case FR_INVALID_NAME:        return(ERR_PATH_NOTFOUND);
    case FR_DENIED:              return(ERR_ACC_DENIED);
    case FR_EXIST:               return(ERR_ACC_DENIED);
    case FR_WRITE_PROTECTED:     return(ERR_WRITE_PROTECT);
    case FR_INVALID_DRIVE:       return(ERR_INVALID_DRIVE);
    case FR_LOCKED:              return(ERR_SHARE_VIOL);
    case FR_TOO_MANY_OPEN_FILES: return(ERR_NOHANDLE);
    case FR_NOT_READY:
    case FR_NOT_ENABLED:
    case FR_NO_FILESYSTEM:
    case FR_TIMEOUT:
    case FR_DISK_ERR:            return(ERR_DRIVE_NOTREADY);
    default:                     return(ERR_ACC_DENIED);
  }
}

/* true if path points at the root directory of a volume ("0:/", "1:") */
static bool path_is_volroot(const char *p) {
  const char *colon = strrchr(p, ':');
  if (colon != NULL) p = colon + 1;
  while ((*p == '/') || (*p == '\\')) p++;
  return(*p == 0);
}

/* grab a search slot, reusing the least recently used one if all are busy.
 * returns the slot index. */
static int srch_alloc(void) {
  int best = 0;
  uint32_t bestlru = 0xFFFFFFFFul;
  int i;
  for (i = 0; i < MAXSEARCH; i++) {
    if (!pm_search[i].inuse) { best = i; break; }
    if (pm_search[i].lru < bestlru) { bestlru = pm_search[i].lru; best = i; }
  }
  pm_search[best].inuse = true;
  pm_search[best].lru = ++pm_srch_clock;
  return(best);
}

/* turns a character c into its upper-case variant */
char upchar(char c) {
  if ((c >= 'a') && (c <= 'z')) c -= ('a' - 'A');
  return(c);
}

/* turns a string into all-upper-case characters, up to n chars max */
static void upstring(char *s, int n) {
  while ((n-- != 0) && (*s != 0)) {
    *s = upchar(*s);
    s++;
  }
}

/* translates a filename string into a fcb-style block ("FILE0001TXT") */
void filename2fcb(char *d, char *s) {
  int i;
  int j;
  /* fill the FCB block with spaces */
  for (i = 0; i < 11; i++) d[i] = ' ';

  /* cover '.' and '..' entries */
  for (i = 0; i < 8; i++) {
    if (s[i] != '.') break;
    d[i] = '.';
  }
  
  /* fill in the filename, up to 8 chars or first dot, whichever comes first */
  j = i;

  for (; i < 8; i++) {
    if ((s[j] == '.') || (s[j] == 0)) break;
    while ((s[j]) == ' ') {
      j++;
    }
    d[i] = upchar(s[j]);
    j++;
  }

  s += i;
  /* fast forward to either the first dot or NULL-terminator */
  for (; ((*s != '.') && (*s != 0)); s++);
  if (*s == 0) return;
  s++; /* skip the dot */
  /* fill in the extension */
  d += 8;
  for (j = 0; j < 3; j++) {
    if ((s[j] == '.') || (s[j] == 0) || (s[j] == ' ')) break;
    *d = upchar(s[j]);
    d++;
  }
}


/* match FCB-style filename to a FCB-style mask ("FILE0001???"), returns 0 if
 * matching, non-zero otherwise - a FCB block is *exactly* 11 bytes long */
static int matchfile2mask(char *msk, char *fil) {
  int i;
  /* compare filename to mask */
  for (i = 0; i < 11; i++) {
    if ((upchar(fil[i]) != upchar(msk[i])) && (msk[i] != '?')) return(-1);
  }
  return(0);
}


/* provides DOS-like attributes for item i, as well as size, filling fprops
 * accordingly. returns item's attributes or 0xff on error.
 * DOS attr flags: 1=RO 2=HID 4=SYS 8=VOL 16=DIR 32=ARCH 64=DEVICE */
//http://elm-chan.org/fsw/ff/doc/chmod.html
unsigned char getitemattr(char *i, struct fileprops *fprops) {
 FRESULT fr;
 FILINFO fno;

 PM_EnableSD();
 fr = f_stat(i, &fno);
 PM_PICO_EnablePSRAM();
 switch (fr) {
     case FR_OK:
        /* zero out struct and set timestamp & fcbname */
        memset(fprops, 0, sizeof(struct fileprops));    
        fprops->ftime = fno.ftime + (fno.fdate << 16); 
        fprops->fsize=(uint32_t) fno.fsize;
        fprops->fattr=fno.fattrib;
        if (fno.altname[0]==0)  //If no alternate name, use name
           { filename2fcb(fprops->fcbname,fno.fname); }
           else filename2fcb(fprops->fcbname,fno.altname);    
// Debug Display               
        PM_INFO("Size: %lu\n", (uint32_t) fno.fsize);
        PM_INFO("Timestamp: %u-%02u-%02u, %02u:%02u\n",
               (fno.fdate >> 9) + 1980, fno.fdate >> 5 & 15, fno.fdate & 31,
               fno.ftime >> 11, fno.ftime >> 5 & 63);
        PM_INFO("Attributes: %c%c%c%c%c\n",
               (fno.fattrib & AM_DIR) ? 'D' : '-',
               (fno.fattrib & AM_RDO) ? 'R' : '-',
               (fno.fattrib & AM_HID) ? 'H' : '-',
               (fno.fattrib & AM_SYS) ? 'S' : '-',
               (fno.fattrib & AM_ARC) ? 'A' : '-');
        break;
     default : return (0xFF); // 0xFF is the error return of this fonction
    }
 return (fno.fattrib);
}

/* set attributes fattr on file i. returns 0 on success, or the negated DOS
 * error code otherwise. */
int setitemattr(char *i, unsigned char fattr) {
  FRESULT f_res;
  PM_EnableSD();  
  f_res = f_chmod(i,fattr,AM_RDO | AM_SYS | AM_HID | AM_ARC);
  PM_PICO_EnablePSRAM();
  PM_INFO("SET %u to %s\n",fattr,i);
  if(f_res != FR_OK) return(-fres2doserr(f_res));
  return 0;  
}

int fs_find(bool Dofindfirst, char *path, char *pattern, struct fileprops *f, unsigned char fattr, uint16_t *srchid)
{

  FRESULT fr;   /* Return value */
  FILINFO fno;  /* File information */
  struct srchstate *s;
  bool ffound=false;

  memset(&fno, 0, sizeof fno);

  if (Dofindfirst)  // findfirst grabs a slot and opens the directory
    {
      int slot = srch_alloc();
      s = &pm_search[slot];
      PM_INFO("Find First -%s%-11s Attr %x (slot %d)\n",path,pattern,fattr,slot);
      PM_EnableSD();
      memset(&s->dir, 0, sizeof s->dir);       // Clean the directory object for Find First
      fr = f_opendir(&s->dir,path);
      PM_PICO_EnablePSRAM();
      if (FR_OK != fr) {
        PM_INFO("f_opendir error: %s (%d)\n", FRESULT_str(fr), fr);
        s->inuse = false;
        // a missing search directory is a "path not found", not a disk error
        if ((fr == FR_NO_FILE) || (fr == FR_NO_PATH) || (fr == FR_INVALID_NAME)) return(-ERR_PATH_NOTFOUND);
        return(-fres2doserr(fr));
         }
      memcpy(s->pattern, pattern, 11);
      s->fattr = fattr;
      // "." and ".." are not reported by f_readdir, but DOS expects them in
      // every subdirectory (DELTREE walks them)
      s->dotstate = path_is_volroot(path) ? 2 : 0;
      *srchid = slot + 1;                      // 0 is kept as "no search"
    } else
    {               // findnext resumes the search owned by srchid
      if ((*srchid == 0) || (*srchid > MAXSEARCH)) return(-ERR_NOMORE_FILES);
      s = &pm_search[*srchid - 1];
      if (!s->inuse) return(-ERR_NOMORE_FILES);
      s->lru = ++pm_srch_clock;
      if (pattern != NULL) memcpy(s->pattern, pattern, 11);
      s->fattr = fattr;
      PM_INFO("Find Next -%-11s Attr %x (slot %d)\n",s->pattern,fattr,*srchid - 1);
    }
  pattern = s->pattern;

  // Volume name requested ? FatFs never reports the label through f_readdir,
  // so answer with the PicoMEM label straight away.
  if (fattr == FAT_VOL)
     {
      filename2fcb(f->fcbname,"PICOMEM");
      f->fattr=FAT_VOL;
      f->fsize=0;
      f->ftime=1;
      return 0;
     }

  // hand out "." then ".." before the real entries, when in a subdirectory
  while (s->dotstate < 2) {
    char dotname[3];
    unsigned char st = s->dotstate;
    s->dotstate++;
    if ((fattr & FAT_DIR) == 0) continue;   // caller does not want directories
    dotname[0] = '.';
    dotname[1] = (st == 1) ? '.' : 0;
    dotname[2] = 0;
    filename2fcb(f->fcbname, dotname);
    if (matchfile2mask(pattern, f->fcbname) != 0) continue;
    f->fsize = 0;
    f->fattr = FAT_DIR;
    f->ftime = 1;
    PM_INFO(" > Return: %-11s (dot entry)\n", f->fcbname);
    return 0;
  }

 do {
  PM_EnableSD();
  fr = f_readdir(&s->dir, &fno);
  PM_PICO_EnablePSRAM();
  if (FR_OK != fr) {
    PM_INFO("f_find error: %s (%d)\n", FRESULT_str(fr), fr);
      return(-fres2doserr(fr));
     }

  PM_INFO("File: %s,%s,  size %d attr %x DirPtr:%d\n",fno.fname,fno.altname,(uint32_t) fno.fsize, fno.fattrib ,s->dir.dptr);

  if (fno.fname[0]==0) return(-ERR_NOMORE_FILES) ;  // > Return directly if no more file

// Does not return Folder, System, Hidden ,except if the bit is set for them
  if ((fattr | (fno.fattrib & 0x16)) == fattr) 
     { // File type match > Compare the name with the pattern
      if (fno.altname[0]==0)  //If no alternate name, use name
      { filename2fcb(f->fcbname,fno.fname); }
       else filename2fcb(f->fcbname,fno.altname);
       PM_INFO(" > Compare %11s with %11s ",f->fcbname,pattern);
       if (matchfile2mask(pattern,f->fcbname) == 0) 
        { PM_INFO(" > Found\n");
          ffound=true;
        } else PM_INFO(" > Not Found\n");
      }

  } while (ffound==false);

  f->fsize=(uint32_t) fno.fsize;
  f->fattr=fno.fattrib;
  f->ftime=fno.ftime + (fno.fdate << 16);
  if (f->ftime==0) f->ftime=1;

  PM_INFO(" > Return: %s, size: %d, attr %x\n", f->fcbname,f->fsize,f->fattr );
  PM_INFO("Timestamp: %u-%02u-%02u, %02u:%02u\n",
               (fno.fdate >> 9) + 1980, fno.fdate >> 5 & 15, fno.fdate & 31,
               fno.ftime >> 11, fno.ftime >> 5 & 63);
  PM_INFO("Attributes: %c%c%c%c%c\n",
               (fno.fattrib & AM_DIR) ? 'D' : '-',
               (fno.fattrib & AM_RDO) ? 'R' : '-',
               (fno.fattrib & AM_HID) ? 'H' : '-',
               (fno.fattrib & AM_SYS) ? 'S' : '-',
               (fno.fattrib & AM_ARC) ? 'A' : '-');
  return 0;
}


/* creates or truncates a file f in directory d with attributes attr. returns 0 on success (and f filled), non-zero otherwise. */
int createfile(struct fileprops *f, char *d, char *fn, unsigned char attr) {
#ifdef BOARD_PICOMEM
  return -1;
#else  
  char fullpath[DIR_MAX];
  FILE *fd;
  sprintf(fullpath, "%s/%s", d, fn);
  /* try to create/truncate the file */
  fd = fopen(fullpath, "wb");
  if (fd == NULL) return(-1);
  fclose(fd);
  /* set attribs (only if FAT drive) */
  if (fatflag != 0) {
    if (setitemattr(fullpath, attr) != 0) PM_ERROR("Error: failed to set attribute %02Xh to '%s'\n", attr, fullpath);
  }
  /* collect and set attributes */
  getitemattr(fullpath, f);
  return(0);
#endif  
}

/* returns disks total size, in bytes, or 0 on error. also sets dfree to the
 * amount of available bytes */
unsigned long long diskinfo(char *path, unsigned long long *dfree) {
  FATFS *fs;
  unsigned long fre_clust;

  /* Get volume information and free clusters of drive */
   PM_EnableSD();
   if (f_getfree(path, &fre_clust, &fs)) return(0);
   PM_PICO_EnablePSRAM();

   PM_INFO("Free Clusters %d Clust size %d",fre_clust,fs->csize);

  /* Return total sectors and free sectors */
   *dfree = (unsigned long long) fre_clust * fs->csize * 512;
   return((unsigned long long) (fs->n_fatent - 2) * fs->csize * 512);  
}

/* try to create directory, return 0 on success, or the negated DOS error */
int makedir(char *d) {
  FRESULT fr;
  PM_EnableSD();
  fr = f_mkdir(d);
  PM_PICO_EnablePSRAM();
    if (FR_OK != fr) {
        PM_INFO("f_mkdir error: %s (%d)\n", FRESULT_str(fr), fr);
        // FR_EXIST -> 5 (access denied), FR_NO_PATH -> 3 (path not found)
        return (-fres2doserr(fr));
    }
  return(0);
}

/* try to remove directory, return 0 on success, or the negated DOS error.
 * Refuses to touch anything that is not a directory. */
int remdir(char *d) {
  FRESULT fr;
  FILINFO fno;

  PM_EnableSD();
  fr = f_stat(d, &fno);
  PM_PICO_EnablePSRAM();
  if (FR_OK != fr) {
    PM_INFO("f_stat error on '%s': %s (%d)\n", d, FRESULT_str(fr), fr);
    return (-ERR_PATH_NOTFOUND);   // a missing directory is a "path not found"
  }
  if ((fno.fattrib & AM_DIR) == 0) {
    PM_INFO("RMDIR refused: '%s' is a file\n", d);
    return (-ERR_ACC_DENIED);
  }

  PM_EnableSD();  
  fr = f_unlink(d);
  PM_PICO_EnablePSRAM();
  if (FR_OK != fr) {
    PM_INFO("f_unlink error: %s (%d)\n", FRESULT_str(fr), fr);
    // FR_DENIED means the directory is not empty -> access denied
    return (-fres2doserr(fr));
}
  return 0;  
}

/* change to directory d, return 0 if worked, non-zero otherwise (used
 * essentially to check whether the directory exists or not) */
int changedir(char *d) {
  FRESULT fr;
  PM_EnableSD();
  fr=f_chdir(d);
  PM_PICO_EnablePSRAM();
    if (FR_OK != fr) {
      PM_INFO("f_chdir error: %s (%d)\n", FRESULT_str(fr), fr);
        return (-1);
    }
  return(0);
}

// Read the file properties after a file is opened
void get_filestats(char *filepath, struct fileprops *f)
{
 FRESULT fr;   /* Return value */
 FILINFO fno;  /* File information */

PM_EnableSD();
fr = f_stat(filepath, &fno);  //  Get the opened file info
PM_PICO_EnablePSRAM();
if (fr!=FR_OK) PM_INFO("! f_stat error : %d\n",fr);

if (strlen(fno.altname)==0)  //If no alternate name, use name
   {
    if (strlen(fno.fname)==0) PM_INFO("Err: Open file with empty name ?\n");
    filename2fcb(f->fcbname,fno.fname);
   }
    else filename2fcb(f->fcbname,fno.altname);

f->fsize=(uint32_t) fno.fsize;
f->fattr=fno.fattrib;
f->ftime=fno.ftime + (fno.fdate << 16);

PM_INFO(" > Opened: %-11s, size: %d, attr %x\n", f->fcbname,(uint32_t) f->fsize,f->fattr );
PM_INFO("Timestamp: %u-%02u-%02u, %02u:%02u\n",
             (fno.fdate >> 9) + 1980, fno.fdate >> 5 & 15, fno.fdate & 31,
             fno.ftime >> 11, fno.ftime >> 5 & 63);
PM_INFO("Attributes: %c%c%c%c%c\n",
             (fno.fattrib & AM_DIR) ? 'D' : '-',
             (fno.fattrib & AM_RDO) ? 'R' : '-',
             (fno.fattrib & AM_HID) ? 'H' : '-',
             (fno.fattrib & AM_SYS) ? 'S' : '-',
             (fno.fattrib & AM_ARC) ? 'A' : '-');
}

/*
int createfile(struct fileprops *f, char *filepath, unsigned char f_mode) {
  FIL *fd;
  FRESULT fr; 
  FILINFO fno;
  uint8_t fileid;

  printf("openfile %s mode %x \n",filepath,f_mode);

  fd = new_fobj(&fileid);                // Search if an handle is free and send the file object
  if (fd == NULL) return(-ERR_NOHANDLE); // No more handle available

  PM_EnableSD();
  fr = f_open(fd, filepath, FA_CREATE_ALWAYS);
  PM_PICO_EnablePSRAM();

  // Return the DOS error code as negative value
	switch(fr)
   {
    case FR_OK: break;
    case FR_NO_FILE: return(-ERR_FILE_NOTFOUND);
    case FR_NO_PATH: return(-ERR_PATH_NOTFOUND);
    case FR_DENIED : return(-ERR_ACC_DENIED);
    default : return (-ERR_ACC_DENIED);
   }

  PM_EnableSD();
  fr = f_stat(filepath, &fno);  //  Get the opened file info
  PM_PICO_EnablePSRAM();
  if (fr!=FR_OK) PM_INFO("! f_stat error : %d\n",fr);

  if (strlen(fno.altname)==0)  //If no alternate name, use name
     {
      if (strlen(fno.fname)==0) PM_INFO("Err: Open file with empty name ?\n");
      filename2fcb(f->fcbname,fno.fname);
     }
      else filename2fcb(f->fcbname,fno.altname);

  f->fsize=(uint32_t) fno.fsize;
  f->fattr=fno.fattrib;
  f->ftime = fno.ftime + (fno.fdate << 16);

  PM_INFO(" > Opened: %-11s, size: %d, attr %x\n", f->fcbname,(uint32_t) f->fsize,f->fattr );
  PM_INFO("Timestamp: %u-%02u-%02u, %02u:%02u\n",
               (fno.fdate >> 9) + 1980, fno.fdate >> 5 & 15, fno.fdate & 31,
               fno.ftime >> 11, fno.ftime >> 5 & 63);
  PM_INFO("Attributes: %c%c%c%c%c\n",
               (fno.fattrib & AM_DIR) ? 'D' : '-',
               (fno.fattrib & AM_RDO) ? 'R' : '-',
               (fno.fattrib & AM_HID) ? 'H' : '-',
               (fno.fattrib & AM_SYS) ? 'S' : '-',
               (fno.fattrib & AM_ARC) ? 'A' : '-');


 return (fileid);
}
*/

// Open a file using the open mode
// return the "fss" / handle number, or error (negative value)
// Open mode : 000 : Read only
//             001 : Write only
//             010 : Read/Write

/* File access mode and open method flags (3rd argument of f_open) */
/*
#define	FA_READ				0x01
#define	FA_WRITE			0x02
#define	FA_OPEN_EXISTING	0x00
#define	FA_CREATE_NEW		  0x04
#define	FA_CREATE_ALWAYS	0x08
#define	FA_OPEN_ALWAYS		0x10
#define	FA_OPEN_APPEND		0x30
*/
int openfile(struct fileprops *f, char *filepath, unsigned char f_mode) {
  FIL *fd;
  FRESULT fr; 
  FILINFO fno;
  uint8_t fileid;

  PM_INFO("openfile %s mode %x %c%c%c%c\n",filepath,f_mode,
    (f_mode & FA_READ) ? 'R' : '-',
    (f_mode & FA_WRITE) ? 'W' : '-',
    (f_mode & FA_CREATE_NEW) ? 'N' : '-',
    (f_mode & FA_CREATE_ALWAYS) ? 'A' : '-');

  fd = new_fobj(&fileid);                // Search if an handle is free and send the file object
  if (fd == NULL) return(-ERR_NOHANDLE); // No more handle available

  PM_EnableSD();
  fr = f_open(fd, filepath, f_mode);
  PM_PICO_EnablePSRAM();
  if (fr!=FR_OK) free_fobj(fileid);      // Free the file object if can't be opened

  // if error, return the DOS error code as negative value
  if (fr != FR_OK) {
    PM_INFO("f_open error: %s (%d)\n", FRESULT_str(fr), fr);
    // "create new" on an existing file must report "file already exists"
    if ((fr == FR_EXIST) && (f_mode & FA_CREATE_NEW)) return(-ERR_FILE_EXISTS);
    return(-fres2doserr(fr));
  }

  PM_EnableSD();
  fr = f_stat(filepath, &fno);  //  Get the opened file info
  PM_PICO_EnablePSRAM();
  if (fr!=FR_OK) PM_INFO("! f_stat error : %d\n",fr);

  if (strlen(fno.altname)==0)  //If no alternate name, use name
     {
      if (strlen(fno.fname)==0) PM_INFO("Err: Open file with empty name ?\n");
      filename2fcb(f->fcbname,fno.fname);
     }
      else filename2fcb(f->fcbname,fno.altname);

  f->fsize=(uint32_t) fno.fsize;
  f->fattr=fno.fattrib;
  f->ftime=fno.ftime + (fno.fdate << 16);

  PM_INFO(" > Opened: %-11s, size:%d, attr:%x, fid:%d\n", f->fcbname,(uint32_t) f->fsize,f->fattr, fileid);
  PM_INFO("Timestamp: %u-%02u-%02u, %02u:%02u\n",
               (fno.fdate >> 9) + 1980, fno.fdate >> 5 & 15, fno.fdate & 31,
                fno.ftime >> 11, fno.ftime >> 5 & 63);
  PM_INFO("Attributes: %c%c%c%c%c\n",
               (f->fattr & AM_DIR) ? 'D' : '-',
               (f->fattr & AM_RDO) ? 'R' : '-',
               (f->fattr & AM_HID) ? 'H' : '-',
               (f->fattr & AM_SYS) ? 'S' : '-',
               (f->fattr & AM_ARC) ? 'A' : '-');

 return (fileid);
}

void closefile(unsigned char fid) {
  FIL *fd;
  FRESULT fr;

  PM_INFO("closefile fid:%d\n",fid);
  fd = get_fobj(fid);
  if (fd!=NULL)
     {
      PM_EnableSD();
      fr = f_close(fd);
      PM_PICO_EnablePSRAM();
      free_fobj(fid);
     }
}


/* reads len bytes from file starting at sector fss, from offset, writes to
 * buff. returns amount of bytes read or a negative value on error. */
int readfile(unsigned char *buff, uint8_t fid, uint32_t offset, uint16_t len) {
  int bread;
  FIL *fd;
  FRESULT fr;

  PM_INFO("readfile id %d, offs:%d, len/%d\n",fid,offset,len);

  fd = get_fobj(fid);
//  PM_INFO(" > FD: %x",fd);
  if (fd == NULL) return(-ERR_INVALID_HAND); // No more handle available

  PM_EnableSD();
  fr = f_lseek(fd,offset);
  if (fr==FR_OK) fr = f_read(fd, buff, len, (UINT *)&bread);
  PM_PICO_EnablePSRAM();
 // PM_INFO(" f_read fr %d, bread%d\n",fr,bread);

// Return the DOS error code as negative value
if (fr != FR_OK) return(-fres2doserr(fr));
  PM_INFO("Data: ");
  for (int i=0;i<16;i++)
      PM_INFO("%x,",buff[i]);
  PM_INFO("\n");
  return(bread);
}

/* writes len bytes from buff to file starting at sect fss, starting at
 * offset. returns amount of bytes written or a negative value on error. */
long writefile(unsigned char *buff, unsigned short fid, unsigned long offset, unsigned short len) {
  int bwritten;
  FIL *fd;
  FRESULT fr;

  PM_INFO("write id %d, offs:%d, len/%d\n",fid,offset,len);

  fd = get_fobj(fid);
//  PM_INFO(" > FD: %x",fd);
  if (fd == NULL) return(-ERR_INVALID_HAND); // No more handle available

  PM_EnableSD();
  fr = f_lseek(fd,offset);
  if (fr==FR_OK) {
    if (len == 0) {
      // DOS: a 0-byte write truncates (or extends) the file at the current
      // position. f_lseek already grew the file if offset was past EOF.
      bwritten = 0;
      fr = f_truncate(fd);
    } else {
      fr = f_write(fd, buff, len, (UINT *)&bwritten);
    }
  }
  PM_PICO_EnablePSRAM();
 
  PM_INFO(" f_write fr %d, bwritten %d\n",fr,bwritten);

// Return the DOS error code as negative value
if (fr != FR_OK) return(-fres2doserr(fr));

  return(bwritten);
  
}

/* remove all files matching the pattern, returns the number of removed files if any found,
 * or -1 on error or if no matching file found */
int delfiles(char *pattern) {
  FRESULT f_res;

  unsigned int i, dcount, fileoffset = 0;
  int ispattern = 0;
  char patterncopy[DIR_MAX];
  char fname[DIR_MAX];
  char dirnamefcb[12];
  char *dir, *fil;
  char filfcb[12];
  struct dirent *diridx;
  DIR dp;
  FILINFO fno;

  /* scan the pattern for '?' characters, and find where the file part starts, also copy the pattern to patterncopy[] */
  for (i = 0; pattern[i] != 0; i++) {
    if (pattern[i] == '?') ispattern = 1;
    if (pattern[i] == '/') fileoffset = i;
    patterncopy[i] = pattern[i];
  }
  patterncopy[i] = 0;
  /* if regular file, delete it right away*/
  if (ispattern == 0) {
    /* DOS DELETE must never remove a directory, and must refuse read-only
     * files - FatFs' f_unlink happily does both */
    PM_EnableSD();
    f_res = f_stat(pattern, &fno);
    PM_PICO_EnablePSRAM();
    if (f_res != FR_OK) return(-ERR_FILE_NOTFOUND);
    if (fno.fattrib & AM_DIR) {
      PM_INFO("DELETE refused: '%s' is a directory\n", pattern);
      return(-ERR_ACC_DENIED);
    }
    if (fno.fattrib & AM_RDO) {
      PM_INFO("DELETE refused: '%s' is read-only\n", pattern);
      return(-ERR_ACC_DENIED);
    }

    PM_EnableSD();
    f_res = f_unlink(pattern);
    PM_PICO_EnablePSRAM();
    if (f_res != FR_OK) return(-fres2doserr(f_res));
    return(1);
  }

  /* if pattern, get dir and fil parts and iterate over all directory */
  dcount = 0;
  dir = patterncopy;
  patterncopy[fileoffset] = 0;
  fil = patterncopy + fileoffset + 1;
  filename2fcb(filfcb, fil);
  /* iterate over the directory and delete whatever is matching the pattern */

  PM_EnableSD();
  f_res = f_opendir(&dp,dir);    
  if(f_res != FR_OK) {
    PM_PICO_EnablePSRAM();
    return (-fres2doserr(f_res));
  }
  PM_PICO_EnablePSRAM();

  for (;;) {
    PM_EnableSD();
    f_res = f_readdir(&dp,&fno);    
    PM_PICO_EnablePSRAM();
    if(f_res != FR_OK || fno.fname[0] == 0) break;            
    /* skip directories and read-only files - DEL touches neither */
    if(fno.fattrib & FAT_DIR) continue;
    if(fno.fattrib & AM_RDO) continue;
      if (fno.altname[0]==0)  //If no alternate name, use name
      { filename2fcb(dirnamefcb,fno.fname); }
       else filename2fcb(dirnamefcb,fno.altname);      
    /* if match, delete the file and continue */
    if (matchfile2mask(filfcb, dirnamefcb) == 0) {
      sprintf(fname, "%s/%s", dir, fno.fname);
      PM_INFO("unlink %s\n",fname);
      PM_EnableSD();      
      f_res = f_unlink(fname);      
      PM_PICO_EnablePSRAM();
      if (f_res != FR_OK) PM_ERROR("failed to delete '%s'\n", fname);
         else dcount++;
    }
  }
  PM_EnableSD();  
  f_closedir(&dp);
  PM_PICO_EnablePSRAM();

  /* a wildcard that matched nothing is "file not found", not a success */
  if (dcount == 0) return(-ERR_FILE_NOTFOUND);
  return(dcount);
}

/* expand a FCB-style name back into a "NAME.EXT" string */
static void fcb2filename(char *dst, const char *fcb) {
  int i, n = 0;
  for (i = 0; i < 8; i++) {
    if (fcb[i] == ' ') break;
    dst[n++] = fcb[i];
  }
  if (fcb[8] != ' ') {
    dst[n++] = '.';
    for (i = 8; i < 11; i++) {
      if (fcb[i] == ' ') break;
      dst[n++] = fcb[i];
    }
  }
  dst[n] = 0;
}

/* splits a full path into its directory part and its file part */
static void explode_dirfile(char *dir, char *file, const char *full) {
  const char *slash = strrchr(full, '/');
  size_t dlen;
  if (slash == NULL) {       /* no directory part at all */
    dir[0] = 0;
    strcpy(file, full);
    return;
  }
  dlen = (size_t)(slash - full);
  memcpy(dir, full, dlen);
  dir[dlen] = 0;
  strcpy(file, slash + 1);
}

/* rename fn1 into fn2, both being full paths. Wildcards ('?', DOS already
 * expanded '*') are supported in the source and destination names.
 * returns 0 on success, or the negated DOS error code. */
int renfile(char *fn1, char *fn2) {
  FRESULT fr;
  char srcdir[DIR_MAX], dstdir[DIR_MAX];
  char srcmask[DIR_MAX], dstmask[DIR_MAX];
  char srcfcb[12], dstfcb[12], curfcb[12], newfcb[12];
  char srcpath[DIR_MAX], dstpath[DIR_MAX], newname[16];
  DIR dp;
  FILINFO fno;
  int i, rcount = 0;

  /* plain rename if neither side holds a wildcard */
  if ((strchr(fn1, '?') == NULL) && (strchr(fn2, '?') == NULL)) {
    PM_EnableSD();
    fr = f_rename(fn1, fn2);
    PM_PICO_EnablePSRAM();
    if (fr != FR_OK) {
      PM_INFO("f_rename error: %s (%d)\n", FRESULT_str(fr), fr);
      return(-fres2doserr(fr));
    }
    return(0);
  }

  /* wildcard rename: expand it here, on the card */
  explode_dirfile(srcdir, srcmask, fn1);
  explode_dirfile(dstdir, dstmask, fn2);
  filename2fcb(srcfcb, srcmask);
  filename2fcb(dstfcb, dstmask);

  PM_EnableSD();
  fr = f_opendir(&dp, srcdir);
  PM_PICO_EnablePSRAM();
  if (fr != FR_OK) return(-fres2doserr(fr));

  for (;;) {
    PM_EnableSD();
    fr = f_readdir(&dp, &fno);
    PM_PICO_EnablePSRAM();
    if ((fr != FR_OK) || (fno.fname[0] == 0)) break;
    if (fno.fattrib & FAT_DIR) continue;

    if (fno.altname[0] == 0) filename2fcb(curfcb, fno.fname);
      else filename2fcb(curfcb, fno.altname);
    if (matchfile2mask(srcfcb, curfcb) != 0) continue;

    /* build the new name: a '?' in the target mask keeps the source char */
    for (i = 0; i < 11; i++) newfcb[i] = (dstfcb[i] == '?') ? curfcb[i] : dstfcb[i];
    newfcb[11] = 0;
    fcb2filename(newname, newfcb);

    sprintf(srcpath, "%s/%s", srcdir, fno.fname);
    sprintf(dstpath, "%s/%s", dstdir, newname);
    PM_INFO("rename '%s' -> '%s'\n", srcpath, dstpath);
    PM_EnableSD();
    fr = f_rename(srcpath, dstpath);
    PM_PICO_EnablePSRAM();
    if (fr != FR_OK) PM_ERROR("failed to rename '%s'\n", srcpath);
      else rcount++;
  }
  PM_EnableSD();
  f_closedir(&dp);
  PM_PICO_EnablePSRAM();

  if (rcount == 0) return(-ERR_FILE_NOTFOUND);
  return(0);
}

/* returns the size of an open file (or a negative DOS error code) */
long getfopsize(unsigned short fid) {
  FIL *fd;
  if (fid >= MAXFILES) return(-ERR_INVALID_HAND);
  fd = get_fobj(fid);
  if (fd == NULL) return(-ERR_INVALID_HAND);
  return((long) f_size(fd));   // live size, not the one cached at open time
}
